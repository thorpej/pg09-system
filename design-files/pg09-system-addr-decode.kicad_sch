File: design-files/pg09-system-addr-decode.kicad_sch (KiCad schematic)
At the start: 8 parts, among them U301 GAL22V10, U302 GAL22V10, U303 GAL22V10, U304 GAL22V10

Commit message: Add text labels to address decoder and interrupt controller sheets.
Other:
- note added: "Address Decoder"
- moved on the sheet: C201, C202, C203, U301, U302, U303, U304

Commit message: Connect the A5-A15 outputs of the 6809 directly to the inputs of the GALs that implement the address decoding logic.
Connections:
- net A10 renamed dA10
- net A11 renamed dA11
- net A12 renamed dA12
- net A13 renamed dA13
- net A14 renamed dA14
- net A15 renamed dA15
- net A5 renamed dA5
- net A6 renamed dA6
- net A7 renamed dA7
- net A8 renamed dA8
- net A9 renamed dA9

Commit message: Move the IOxSEL outputs to make PCB layout easier.
Connections:
- net ~{BROMSEL}: now also U301.14 (IO1); no longer U301.22 (IO9)
- net ~{FRAMSEL}: now also U302.14 (IO1); no longer U302.22 (IO9)
- net ~{FROMSEL}: now also U301.15 (IO2); no longer U301.23 (IO10)
- net ~{HBRAMSEL}: now also U302.15 (IO2); no longer U302.23 (IO10)
- net ~{IO0SEL}: now also U301.16 (IO3); no longer U301.14 (IO1)
- net ~{IO10SEL}: now also U302.18 (IO5); no longer U302.16 (IO3)
- net ~{IO11SEL}: now also U302.19 (IO6); no longer U302.17 (IO4)
- net ~{IO12SEL}: now also U302.20 (IO7); no longer U302.18 (IO5)
- net ~{IO13SEL}: now also U302.21 (IO8); no longer U302.19 (IO6)
- net ~{IO14SEL}: now also U302.22 (IO9); no longer U302.20 (IO7)
- net ~{IO15SEL}: now also U302.23 (IO10); no longer U302.21 (IO8)
- net ~{IO16SEL}: now also U303.16 (IO3); no longer U303.14 (IO1)
- net ~{IO17SEL}: now also U303.17 (IO4); no longer U303.15 (IO2)
- net ~{IO18SEL}: now also U303.18 (IO5); no longer U303.16 (IO3)
- net ~{IO19SEL}: now also U303.19 (IO6); no longer U303.17 (IO4)
- net ~{IO1SEL}: now also U301.17 (IO4); no longer U301.15 (IO2)
- net ~{IO20SEL}: now also U303.20 (IO7); no longer U303.18 (IO5)
- net ~{IO21SEL}: now also U303.21 (IO8); no longer U303.19 (IO6)
- net ~{IO22SEL}: now also U303.22 (IO9); no longer U303.20 (IO7)
- net ~{IO23SEL}: now also U303.23 (IO10); no longer U303.21 (IO8)
- net ~{IO24SEL}: now also U304.16 (IO3); no longer U304.14 (IO1)
- net ~{IO25SEL}: now also U304.17 (IO4); no longer U304.15 (IO2)
- net ~{IO26SEL}: now also U304.18 (IO5); no longer U304.16 (IO3)
- net ~{IO27SEL}: now also U304.19 (IO6); no longer U304.17 (IO4)
- net ~{IO28SEL}: now also U304.20 (IO7); no longer U304.18 (IO5)
- net ~{IO29SEL}: now also U304.21 (IO8); no longer U304.19 (IO6)
- net ~{IO2SEL}: now also U301.18 (IO5); no longer U301.16 (IO3)
- net ~{IO30SEL}: now also U304.22 (IO9); no longer U304.20 (IO7)
- net ~{IO31SEL}: now also U304.23 (IO10); no longer U304.21 (IO8)
- net ~{IO3SEL}: now also U301.19 (IO6); no longer U301.17 (IO4)
- net ~{IO4SEL}: now also U301.20 (IO7); no longer U301.18 (IO5)
- net ~{IO5SEL}: now also U301.21 (IO8); no longer U301.19 (IO6)
- net ~{IO6SEL}: now also U301.22 (IO9); no longer U301.20 (IO7)
- net ~{IO7SEL}: now also U301.23 (IO10); no longer U301.21 (IO8)
- net ~{IO8SEL}: now also U302.16 (IO3); no longer U302.14 (IO1)
- net ~{IO9SEL}: now also U302.17 (IO4); no longer U302.15 (IO2)
