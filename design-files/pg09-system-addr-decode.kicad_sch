File: design-files/pg09-system-addr-decode.kicad_sch (KiCad schematic)
At the start: 8 parts, among them U301 GAL22V10, U302 GAL22V10, U303 GAL22V10, U304 GAL22V10

Commit message: Add pull-ups to all of the address decoder outputs.  Also connect pull-ups to /NMI, /IRQ, /FIRQ, and /HALT (using 4 spares in a resistor network on the address decoder).
Parts:
- added RN401 (x5): 10K, Resistor_THT:R_Array_SIP9, symbol Device:R_Network08
Connections:
- net +5V: now also RN401.1 (common), RN401.1 (common), RN401.1 (common), RN401.1 (common), RN401.1 (common)
- net ~{BROMSEL}: now also RN401.2 (R1)
- net ~{FRAMSEL}: now also RN401.4 (R3)
- net ~{FROMSEL}: now also RN401.3 (R2)
- net ~{HBRAMSEL}: now also RN401.5 (R4)
- net ~{IO0SEL}: now also RN401.9 (R8), RN401.9 (R8)
- net ~{IO10SEL}: now also RN401.7 (R6)
- net ~{IO11SEL}: now also RN401.6 (R5)
- net ~{IO12SEL}: now also RN401.5 (R4)
- net ~{IO13SEL}: now also RN401.4 (R3)
- net ~{IO14SEL}: now also RN401.3 (R2)
- net ~{IO15SEL}: now also RN401.2 (R1)
- net ~{IO16SEL}: now also RN401.9 (R8)
- net ~{IO17SEL}: now also RN401.8 (R7)
- net ~{IO18SEL}: now also RN401.7 (R6)
- net ~{IO19SEL}: now also RN401.6 (R5)
- net ~{IO1SEL}: now also RN401.8 (R7), RN401.8 (R7)
- net ~{IO20SEL}: now also RN401.5 (R4)
- net ~{IO21SEL}: now also RN401.4 (R3)
- net ~{IO22SEL}: now also RN401.3 (R2)
- net ~{IO23SEL}: now also RN401.2 (R1)
- net ~{IO2SEL}: now also RN401.7 (R6), RN401.7 (R6)
- net ~{IO3SEL}: now also RN401.6 (R5), RN401.6 (R5)
- net ~{IO4SEL}: now also RN401.5 (R4), RN401.5 (R4)
- net ~{IO5SEL}: now also RN401.4 (R3), RN401.4 (R3)
- net ~{IO6SEL}: now also RN401.3 (R2), RN401.3 (R2)
- net ~{IO7SEL}: now also RN401.2 (R1), RN401.2 (R1)
- net ~{IO8SEL}: now also RN401.9 (R8)
- net ~{IO9SEL}: now also RN401.8 (R7)
- new net ~{FIRQ}: RN401.8 (R7)
- new net ~{HALT}: RN401.9 (R8)
- new net ~{IRQ}: RN401.7 (R6)
- new net ~{NMI}: RN401.6 (R5)

Commit message: Assign a bunch of footprints.
Parts:
- C201, C202, C203: footprint (none) -> Capacitor_THT:C_Disc_D6.0mm_W4.4mm_P5.00mm
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 123.19 177.8 0)
+    (property "Footprint" "Capacitor_THT:C_Disc_D6.0mm_W4.4mm_P5.00mm" (at 123.19 177.8 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 113.03 177.8 0)
+    (property "Footprint" "Capacitor_THT:C_Disc_D6.0mm_W4.4mm_P5.00mm" (at 113.03 177.8 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 143.51 177.8 0)
+    (property "Footprint" "Capacitor_THT:C_Disc_D6.0mm_W4.4mm_P5.00mm" (at 143.51 177.8 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 133.35 177.8 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "Capacitor_THT:C_Disc_D6.0mm_W4.4mm_P5.00mm" (at 133.35 177.8 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Fix various errors and omissions discovered while working on the first cut of the PCB layout.
Connections:
- net ~{IO0SEL}: no longer RN401.9 (R8)
- net ~{IO1SEL}: no longer RN401.8 (R7)
- net ~{IO24SEL}: now also RN401.9 (R8)
- net ~{IO25SEL}: now also RN401.8 (R7)
- net ~{IO26SEL}: now also RN401.7 (R6)
- net ~{IO27SEL}: now also RN401.6 (R5)
- net ~{IO28SEL}: now also RN401.5 (R4)
- net ~{IO29SEL}: now also RN401.4 (R3)
- net ~{IO2SEL}: no longer RN401.7 (R6)
- net ~{IO30SEL}: now also RN401.3 (R2)
- net ~{IO31SEL}: now also RN401.2 (R1)
- net ~{IO3SEL}: no longer RN401.6 (R5)
- net ~{IO4SEL}: no longer RN401.5 (R4)
- net ~{IO5SEL}: no longer RN401.4 (R3)
- net ~{IO6SEL}: no longer RN401.3 (R2)
- net ~{IO7SEL}: no longer RN401.2 (R1)
Changed lines of the file:
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@@
     )
   )
-  (global_label "~{IO6SEL}" (shape input) (at 224.79 109.22 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 215.3528 109.22 0)
+  (global_label "~{IO30SEL}" (shape input) (at 224.79 109.22 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 214.1433 109.22 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
-  (global_label "~{IO1SEL}" (shape input) (at 234.95 121.92 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 225.5128 121.92 0)
+  (global_label "~{IO25SEL}" (shape input) (at 234.95 121.92 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 224.3033 121.92 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
-  (global_label "~{IO5SEL}" (shape input) (at 234.95 111.76 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 225.5128 111.76 0)
+  (global_label "~{IO29SEL}" (shape input) (at 234.95 111.76 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 224.3033 111.76 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
-  (global_label "~{IO4SEL}" (shape input) (at 224.79 114.3 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 215.3528 114.3 0)
+  (global_label "~{IO28SEL}" (shape input) (at 224.79 114.3 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 214.1433 114.3 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
-  (global_label "~{IO3SEL}" (shape input) (at 234.95 116.84 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 225.5128 116.84 0)
+  (global_label "~{IO27SEL}" (shape input) (at 234.95 116.84 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 224.3033 116.84 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
-  (global_label "~{IO0SEL}" (shape input) (at 224.79 124.46 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 215.3528 124.46 0)
+  (global_label "~{IO24SEL}" (shape input) (at 224.79 124.46 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 214.1433 124.46 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
-  (global_label "~{IO2SEL}" (shape input) (at 224.79 119.38 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 215.3528 119.38 0)
+  (global_label "~{IO26SEL}" (shape input) (at 224.79 119.38 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 214.1433 119.38 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
-  (global_label "~{IO7SEL}" (shape input) (at 234.95 106.68 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 225.5128 106.68 0)
-      (effects (font (size 1.27 1.27)) (justify right) hide)
-    )
+  (global_label "~{IO31SEL}" (shape input) (at 234.95 106.68 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 224.3033 106.68 0)
+      (effects (font (size 1.27 1.27)) (justify right) hide)
+    )

Commit message: Specify a physically smaller bypass cap.
Parts:
- C201, C202, C203: footprint Capacitor_THT:C_Disc_D6.0mm_W4.4mm_P5.00mm -> Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Capacitor_THT:C_Disc_D6.0mm_W4.4mm_P5.00mm" (at 123.19 177.8 0)
+    (property "Footprint" "Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm" (at 123.19 177.8 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Capacitor_THT:C_Disc_D6.0mm_W4.4mm_P5.00mm" (at 113.03 177.8 0)
+    (property "Footprint" "Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm" (at 113.03 177.8 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Capacitor_THT:C_Disc_D6.0mm_W4.4mm_P5.00mm" (at 143.51 177.8 0)
+    (property "Footprint" "Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm" (at 143.51 177.8 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Capacitor_THT:C_Disc_D6.0mm_W4.4mm_P5.00mm" (at 133.35 177.8 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm" (at 133.35 177.8 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
