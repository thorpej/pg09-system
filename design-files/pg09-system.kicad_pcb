# Repository thorpej/pg09-system

File README.md:

# 6809 Playground

Welcome to my 6809 Playground!  This project is about building a general
purpose 8-bit computer based on the Motorola 6809 CPU.  While this is
definitely a retro-computer project, I'm not going to be dogmatic about
it -- modern gadgets that add value to the project will have a home here,
too.

The whole point of this exercise is to learn-by-doing and have fun in the
process.  I have a few ideas about how I want the project to go, but it
may veer this way or that as it progresses.  We'll see!

I invite you to follow along with this [YouTube playlist](https://youtube.com/playlist?list=PL_E3Je1H0xrvq1AOL1zlwj3LmrBiK8FJb).  As each
installment is posted, this README will be updated with additional information
about the that installment, including links to data sheets and a parts list.

If you learn something from this, if you decide to build one of these
yourself, or if it inspires you embark on a similar adventure on your own,
I would love to hear from you!

## 01 - Introduction

In the first installment, I briefly introduce the project and provide some
background.

Video link: [01 - Introduction](https://youtu.be/d_VZdUXh_dU)

## 02 - Clock Generator

In the second installment, I describe the design and implementation of
the clock generator circuitry.

Major components:
* [74ACT163](https://www.ti.com/lit/ds/symlink/cd74act163.pdf) binary counter
* [74ACT109](https://www.ti.com/lit/ds/symlink/cd74act109.pdf) dual J-/K flip-flop
* [Lattice GAL22V10](https://web.mit.edu/6.115/www/document/gal22v10.pdf) or
  [Atmel ATF22V10](https://www.mouser.com/datasheet/2/268/doc0735-1369018.pdf)
  electrically-eraseable programmable logic device

Video link: [02 - Clock Generator](https://youtu.be/Hb_b3B4GNCY)

## 03 - Reset Generator

This the third installment, I describe how the reset generator works.

Major components:
* [Dallas Semiconductor DS1813](https://www.mouser.com/datasheet/2/609/DS1813-3122044.pdf)

Video link: [03 - Reset Generator](https://youtu.be/o6EI-TFBSVA)

## KiCad design design-files/pg09-system.kicad_pcb

Board: 4 copper layers, 306.0 x 244.0 mm, 167 parts (0 on the bottom side), 269 nets.

Parts:
C101, C102, C103, C104, C105, C106, C201, C202, C203, C204, C301, C302, C303, C304, C305, C401, C402, C403, C404, C405, C406, C407, C408, C409, C410, C411, C412, C413, C414, C501, C502, C503, C601, C602, C603, C604, C605, C606, C607, C608, C609, C610, C701, C703, C805, C1001, C1002, C1003: 0.1µF; C_Disc_D3.8mm_W2.6mm_P2.50mm
C107: 10µF 50V; CP_Radial_D8.0mm_P2.50mm
C108: 100µF 16V; CP_Radial_D6.3mm_P2.50mm
C801: 4700µF 16V; CP_Radial_D12.5mm_P5.00mm
C802, C803, C804: 470µF 25V; CP_Radial_D10.0mm_P5.00mm
D101, D1002: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D801: Power; LED_D3.0mm
D1001: SD Card; LED_D3.0mm
H101, H102, H103, H104, H105, H106, H107, H108, H109, H110: MountingHole_Pad; MountingHole_4.3mm_M4_Pad_Via
H1001, H1002, H1003, H1004: MountingHole_Pad; MountingHole_2.2mm_M2_Pad_Via
J101: Front Panel; PinHeader_2x08_P2.54mm_Vertical
J201: Clock Speed; PinHeader_2x03_P2.54mm_Vertical
J801: ATX-24; Molex_Mini-Fit_Jr_5566-24A_2x12_P4.20mm_Vertical
J802: #PS_ON; PinHeader_1x02_P2.54mm_Vertical
J803: PSU-CTRL console; PinHeader_1x03_P2.54mm_Vertical
J901: Expansion 1; PinHeader_2x20_P2.54mm_Vertical
J902: Expansion 1 ext; PinHeader_2x08_P2.54mm_Vertical
J903: Expansion 2; PinHeader_2x20_P2.54mm_Vertical
J904: Expansion 2 ext; PinHeader_2x08_P2.54mm_Vertical
J905: Expansion 3; PinHeader_2x20_P2.54mm_Vertical
J906: Expansion 3 ext; PinHeader_2x08_P2.54mm_Vertical
J907: Expansion 4; PinHeader_2x20_P2.54mm_Vertical
J908: Expansion 4 ext; PinHeader_2x08_P2.54mm_Vertical
J1001: Adafruit MicroSD Card Breakout Board+; PinHeader_1x08_P2.54mm_Vertical
J1101: PS/2 Keyboard; PinHeader_1x06_P2.54mm_Horizontal
J1102, J1103: SNES-Controller-Socket; SNES-Connector_Vertical
R102: 3K3; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R301, R1001, R1002: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R801, R802, R1004, R1005: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RN101, RN102, RN201, RN301, RN302, RN303, RN304, RN305, RN306, RN401, RN402, RN403, RN404: 10K; R_Array_SIP9
SW101: NMI; SW_PUSH_6mm
SW102: Reset; SW_PUSH_6mm
SW801: Power; SW_PUSH_6mm
U101: MC6809E; DIP-40_W15.24mm_Socket
U102, U106, U204, U301, U302, U411: GAL22V10; DIP-24_W7.62mm_Socket
U103, U104, U105: 74AHCT245; DIP-20_W7.62mm_Socket
U107, U108: DS1813; TO-92_Inline
U201: CD74ACT109; DIP-16_W7.62mm_Socket
U202: CD74ACT163; DIP-16_W7.62mm_Socket
U303, U304, U401: W65C21S; DIP-40_W15.24mm_Socket
U305: 74AHC138; DIP-16_W7.62mm_Socket
U402, U403, U404: 74HC04; DIP-14_W7.62mm_Socket
U405, U406, U407, U408: 74HC00; DIP-14_W7.62mm_Socket
U409, U410: 74HC148; DIP-16_W7.62mm_Socket
U413, U414, U803: 74AHC374; DIP-20_W7.62mm_Socket
U415: 74AHC05; DIP-14_W7.62mm_Socket
U501: SST39SF040; DIP_Socket-32_W11.9_W12.7_W15.24_W17.78_W18.5_3M_232-1285-0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
U502, U503: 74AHC08; DIP-14_W7.62mm_Socket
U601: 74AHC139; DIP-16_W7.62mm_Socket
U602: AS6C6264-55PCN; DIP-28_W15.24mm_Socket
U603, U604, U605, U606, U607, U608: AS6C4008-55PCN; DIP-32_W15.24mm_Socket
U609, U610: 74AHC157; DIP-16_W7.62mm_Socket
U701: TL16C2552; PLCC-44_THT-Socket
U702: Ali_Express_FTDI_Breakout
U705: Adafruit_FTDI_Friend; PinHeader_1x06_P2.54mm_Horizontal
U801: Adafruit_Metro_Mini; DIP-28_W15.24mm_Socket
U1001: W65C22S; DIP-40_W15.24mm_Socket
U1002: 74HC86; DIP-14_W7.62mm_Socket
U1003: 74HC164; DIP-14_W7.62mm_Socket
U1101: VERA-Module
X201: 32.0000MHz; Oscillator_DIP-8
X701: 1.8432MHz; Oscillator_DIP-8

Connections:
+3V3: C804.1, J801.1 (+3.3V), J801.2 (+3.3V), J801.12 (+3.3V), J801.13 (+3.3V)
+5V: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C201.1, C202.1, C203.1, C204.1, C301.1, C302.1, C303.1, C304.1, C305.1, C401.1, C402.1, C403.1, C404.1, C405.1, C406.1, C407.1, C408.1, C409.1, C410.1, C411.1, C412.1, C413.1, C414.1, C501.1, C502.1, C503.1, C601.1, C602.1, C603.1, C604.1, C605.1, C606.1, C607.1, C608.1, C609.1, C610.1, C701.1, C703.1, C801.1, C805.1, C1001.1, C1002.1, C1003.1, D101.1 (K), J801.4 (+5V), J801.6 (+5V), J801.21 (+5V), J801.22 (+5V), J801.23 (+5V), J901.2, J903.2, J905.2, J907.2, J1001.1, R102.2, R1001.2, R1002.2, RN101.1 (common), RN102.1 (common), RN201.1 (common), RN301.1 (common), RN302.1 (common), RN303.1 (common), RN401.1 (common), RN402.1 (common), U101.7 (VCC), U102.24 (VCC), U103.20 (VCC), U104.20 (VCC), U105.20 (VCC), U106.24 (VCC), U107.2 (Vcc), U201.1 (~R)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
+5VSB: J801.9 (+5VSB), U801.4 (5V)
+12V: C802.1, J801.10 (+12V), J801.11 (+12V), J902.15, J904.15, J906.15, J908.15
-12V: C803.2, J801.14 (-12V), J902.16, J904.16, J906.16, J908.16
/Interrupt controller/INT_0: U402.2, U405.1
/Interrupt controller/INT_1: U402.4, U405.4
/Interrupt controller/INT_2: U402.6, U405.9
/Interrupt controller/INT_3: U402.8, U405.12
/Interrupt controller/INT_4: U402.10, U406.1
/Interrupt controller/INT_5: U402.12, U406.4
/Interrupt controller/INT_6: U403.2, U406.9
/Interrupt controller/INT_7: U403.4, U406.12
/Interrupt controller/INT_8: U403.6, U407.1
/Interrupt controller/INT_9: U403.8, U407.4
/Interrupt controller/INT_10: U403.10, U407.9
/Interrupt controller/INT_11: U403.12, U407.12
/Interrupt controller/INT_12: U404.2, U408.1
/Interrupt controller/INT_13: U404.4, U408.4
/Interrupt controller/INT_14: U404.6, U408.9
/Interrupt controller/INT_15: U404.8, U408.12
/Interrupt controller/INT_E0: RN403.2 (R1), U401.2 (PA0), U405.2
/Interrupt controller/INT_E1: RN403.3 (R2), U401.3 (PA1), U405.5
/Interrupt controller/INT_E2: RN403.4 (R3), U401.4 (PA2), U405.10
/Interrupt controller/INT_E3: RN403.5 (R4), U401.5 (PA3), U405.13
/Interrupt controller/INT_E4: RN403.6 (R5), U401.6 (PA4), U406.2
/Interrupt controller/INT_E5: RN403.7 (R6), U401.7 (PA5), U406.5
/Interrupt controller/INT_E6: RN403.8 (R7), U401.8 (PA6), U406.10
/Interrupt controller/INT_E7: RN403.9 (R8), U401.9 (PA7), U406.13
/Interrupt controller/INT_E8: RN404.2 (R1), U401.10 (PB0), U407.2
/Interrupt controller/INT_E9: RN404.3 (R2), U401.11 (PB1), U407.5
/Interrupt controller/INT_E10: RN404.4 (R3), U401.12 (PB2), U407.10
/Interrupt controller/INT_E11: RN404.5 (R4), U401.13 (PB3), U407.13
/Interrupt controller/INT_E12: RN404.6 (R5), U401.14 (PB4), U408.2
/Interrupt controller/INT_E13: RN404.7 (R6), U408.5
/Interrupt controller/INT_E14: RN404.8 (R7), U401.16 (PB6), U408.10
/Interrupt controller/INT_E15: RN404.9 (R8), U401.17 (PB7), U408.13
/Interrupt controller/INT_L0: U409.9 (S0), U411.5 (I5)
/Interrupt controller/INT_L1: U409.7 (S1), U411.4 (I4)
/Interrupt controller/INT_L2: U409.6 (S2), U411.3 (I3)
/Interrupt controller/INT_LA: U409.15 (EO), U411.6 (I6)
/Interrupt controller/INT_O0: U405.3, U409.4 (I7)
/Interrupt controller/INT_O1: U405.6, U409.3 (I6)
/Interrupt controller/INT_O2: U405.8, U409.2 (I5)
/Interrupt controller/INT_O3: U405.11, U409.1 (I4)
/Interrupt controller/INT_O4: U406.3, U409.13 (I3)
/Interrupt controller/INT_O5: U406.6, U409.12 (I2)
/Interrupt controller/INT_O6: U406.8, U409.11 (I1)
/Interrupt controller/INT_O7: U406.11, U409.10 (IO)
/Interrupt controller/INT_O8: U407.3, U410.4 (I7)
/Interrupt controller/INT_O9: U407.6, U410.3 (I6)
/Interrupt controller/INT_O10: U407.8, U410.2 (I5)
/Interrupt controller/INT_O11: U407.11, U410.1 (I4)
/Interrupt controller/INT_O12: U408.3, U410.13 (I3)
/Interrupt controller/INT_O13: U408.6, U410.12 (I2)
/Interrupt controller/INT_O14: U408.8, U410.11 (I1)
/Interrupt controller/INT_O15: U408.11, U410.10 (IO)
/Interrupt controller/INT_U0: U410.9 (S0), U411.9 (I9)
/Interrupt controller/INT_U1: U410.7 (S1), U411.8 (I8)
/Interrupt controller/INT_U2: U410.6 (S2), U411.7 (I7)
/Interrupt controller/INT_UA: U410.15 (EO), U411.10 (I10)
/Power Supply/PSU_CTRL_D0: U801.20 (D5), U803.2 (O0)
/Power Supply/PSU_CTRL_D1: U801.19 (D4), U803.5 (O1)
/RAM/LRBS0: U603.31 (A15), U604.31 (A15), U605.31 (A15), U606.31 (A15), U609.4 (Za)
/RAM/LRBS1: U603.2 (A16), U604.2 (A16), U605.2 (A16), U606.2 (A16), U609.7 (Zb)
/RAM/LRBS2: U603.30 (A17), U604.30 (A17), U605.30 (A17), U606.30 (A17), U609.9 (Zc)
/RAM/LRBS3: U603.1 (A18), U604.1 (A18), U605.1 (A18), U606.1 (A18), U609.12 (Zd)
/SPI SD Card Interface/SD_CD: J1001.8, R1001.1, U1001.4 (PA2), U1001.39 (CA2)
/SPI SD Card Interface/SD_CS: J1001.7, R1002.1, R1004.1, R1005.1, U415.6
/SPI SD Card Interface/SD_MISO: J1001.5, U1003.2 (B)
/SPI SD Card Interface/SD_MOSI: J1001.6, U1002.6
/SPI SD Card Interface/SD_MOSI_INV: U1001.2 (PA0), U1002.4
/SPI SD Card Interface/SD_SCK: J1001.4, U1002.3, U1002.10, U1003.8 (CLK)
A0: J901.1, J903.1, J905.1, J907.1, U102.3 (I3), U104.2 (A0), U303.36 (RS0), U304.36 (RS0), U305.1 (A0), U401.36 (RS0), U411.23 (IO10), U501.12 (A0), U602.10 (A0), U603.12 (A0), U604.12 (A0), U605.12 (A0), U606.12 (A0), U607.12 (A0), U608.12 (A0), U701.10 (A0), U1001.38 (RS0), U1101.19 (A0)
A1: J901.3, J903.3, J905.3, J907.3, U102.4 (I4), U104.3 (A1), U303.35 (RS1), U304.35 (RS1), U305.2 (A1), U401.35 (RS1), U411.22 (IO9), U501.11 (A1), U602.9 (A1), U603.11 (A1), U604.11 (A1), U605.11 (A1), U606.11 (A1), U607.11 (A1), U608.11 (A1), U701.14 (A1), U1001.37 (RS1), U1101.20 (A1)
A2: J901.5, J903.5, J905.5, J907.5, U102.5 (I5), U104.4 (A2), U303.24 (CS1), U411.21 (IO8), U501.10 (A2), U602.8 (A2), U603.10 (A2), U604.10 (A2), U605.10 (A2), U606.10 (A2), U607.10 (A2), U608.10 (A2), U701.15 (A2), U1001.36 (RS2), U1101.17 (A2)
A3: J901.7, J903.7, J905.7, J907.7, U102.6 (I6), U104.5 (A3), U305.6 (E3), U411.20 (IO7), U501.9 (A3), U602.7 (A3), U603.9 (A3), U604.9 (A3), U605.9 (A3), U606.9 (A3), U607.9 (A3), U608.9 (A3), U1001.35 (RS3), U1101.18 (A3)
A4: J901.9, J903.9, J905.9, J907.9, U102.7 (I7), U104.6 (A4), U305.5 (E2), U401.22 (CS0), U401.24 (CS1), U411.19 (IO6), U501.8 (A4), U602.6 (A4), U603.8 (A4), U604.8 (A4), U605.8 (A4), U606.8 (A4), U607.8 (A4), U608.8 (A4), U1101.15 (A4)
A5: U104.7 (A5), U301.1 (I1/CLK), U302.1 (I1/CLK), U413.15 (O5), U501.7 (A5), U602.5 (A5), U603.7 (A5), U604.7 (A5), U605.7 (A5), U606.7 (A5), U607.7 (A5), U608.7 (A5)
A6: U104.8 (A6), U301.2 (I2), U302.2 (I2), U413.16 (O6), U501.6 (A6), U602.4 (A6), U603.6 (A6), U604.6 (A6), U605.6 (A6), U606.6 (A6), U607.6 (A6), U608.6 (A6)
A7: U104.9 (A7), U301.3 (I3), U302.3 (I3), U413.19 (O7), U501.5 (A7), U602.3 (A7), U603.5 (A7), U604.5 (A7), U605.5 (A7), U606.5 (A7), U607.5 (A7), U608.5 (A7)
A8: U105.2 (A0), U301.4 (I4), U302.4 (I4), U414.2 (O0), U501.27 (A8), U602.25 (A8), U603.27 (A8), U604.27 (A8), U605.27 (A8), U606.27 (A8), U607.27 (A8), U608.27 (A8)
A9: U105.3 (A1), U301.5 (I5), U302.5 (I5), U414.5 (O1), U501.26 (A9), U602.24 (A9), U603.26 (A9), U604.26 (A9), U605.26 (A9), U606.26 (A9), U607.26 (A9), U608.26 (A9)
A10: U105.4 (A2), U301.6 (I6), U302.6 (I6), U414.6 (O2), U501.23 (A10), U602.21 (A10), U603.23 (A10), U604.23 (A10), U605.23 (A10), U606.23 (A10), U607.23 (A10), U608.23 (A10)
A11: U105.5 (A3), U301.7 (I7), U302.7 (I7), U414.9 (O3), U501.25 (A11), U602.23 (A11), U603.25 (A11), U604.25 (A11), U605.25 (A11), U606.25 (A11), U607.25 (A11), U608.25 (A11)
A12: U105.6 (A4), U301.8 (I8), U302.8 (I8), U414.12 (O4), U501.4 (A12), U602.2 (A12), U603.4 (A12), U604.4 (A12), U605.4 (A12), U606.4 (A12), U607.4 (A12), U608.4 (A12)
A13: U105.7 (A5), U301.9 (I9), U302.9 (I9), U414.15 (O5), U603.28 (A13), U604.28 (A13), U605.28 (A13), U606.28 (A13)
A14: U105.8 (A6), U301.10 (I10), U302.10 (I10), U414.16 (O6), U603.3 (A14), U604.3 (A14), U605.3 (A14), U606.3 (A14), U609.1 (S), U610.1 (S)
A15: U105.9 (A7), U301.11 (I11), U302.11 (I11), U414.19 (O7), U601.1 (E)
BA: U101.6 (BA), U106.1 (I1/CLK)
BS: U101.5 (BS), U106.2 (I2), U411.1 (I1/CLK)
CLK_4MHz: U202.12 (Q2), U204.4 (I4)
CLK_8MHz: U202.13 (Q1), U204.3 (I3)
CLK_16MHz: U202.14 (Q0), U204.2 (I2)
D0: J901.4, J903.4, J905.4, J907.4, RN102.2 (R1), U103.2 (A0), U204.21 (IO8), U303.33 (D0), U304.33 (D0), U401.33 (D0), U414.3 (D0), U501.13 (D0), U602.11 (DQ0), U603.13 (DQ0), U604.13 (DQ0), U605.13 (DQ0), U606.13 (DQ0), U607.13 (DQ0), U608.13 (DQ0), U701.2 (D0), U803.3 (D0), U1001.33 (D0), U1101.10 (D0)
D1: J901.6, J903.6, J905.6, J907.6, RN102.3 (R2), U103.3 (A1), U204.20 (IO7), U303.32 (D1), U304.32 (D1), U401.32 (D1), U414.4 (D1), U501.14 (D1), U602.12 (DQ1), U603.14 (DQ1), U604.14 (DQ1), U605.14 (DQ1), U606.14 (DQ1), U607.14 (DQ1), U608.14 (DQ1), U701.3 (D1), U803.4 (D1), U1001.32 (D1), U1101.9 (D1)
D2: J901.8, J903.8, J905.8, J907.8, RN102.4 (R3), U103.4 (A2), U204.19 (IO6), U303.31 (D2), U304.31 (D2), U401.31 (D2), U414.7 (D2), U501.15 (D2), U602.13 (DQ2), U603.15 (DQ2), U604.15 (DQ2), U605.15 (DQ2), U606.15 (DQ2), U607.15 (DQ2), U608.15 (DQ2), U701.4 (D2), U803.7 (D2), U1001.31 (D2), U1101.8 (D2)
D3: J901.10, J903.10, J905.10, J907.10, RN102.5 (R4), U103.5 (A3), U204.18 (IO5), U303.30 (D3), U304.30 (D3), U401.30 (D3), U414.8 (D3), U501.17 (D3), U602.15 (DQ3), U603.17 (DQ3), U604.17 (DQ3), U605.17 (DQ3), U606.17 (DQ3), U607.17 (DQ3), U608.17 (DQ3), U701.5 (D3), U803.8 (D3), U1001.30 (D3), U1101.7 (D3)
D4: J901.12, J903.12, J905.12, J907.12, RN102.6 (R5), U103.6 (A4), U204.17 (IO4), U303.29 (D4), U304.29 (D4), U401.29 (D4), U414.13 (D4), U501.18 (D4), U602.16 (DQ4), U603.18 (DQ4), U604.18 (DQ4), U605.18 (DQ4), U606.18 (DQ4), U607.18 (DQ4), U608.18 (DQ4), U701.6 (D4), U803.13 (D4), U1001.29 (D4), U1101.6 (D4)
D5: J901.14, J903.14, J905.14, J907.14, RN102.7 (R6), U103.7 (A5), U204.16 (IO3), U303.28 (D5), U304.28 (D5), U401.28 (D5), U413.14 (D5), U414.14 (D5), U501.19 (D5), U602.17 (DQ5), U603.19 (DQ5), U604.19 (DQ5), U605.19 (DQ5), U606.19 (DQ5), U607.19 (DQ5), U608.19 (DQ5), U701.7 (D5), U803.14 (D5), U1001.28 (D5), U1101.5 (D5)
D6: J901.16, J903.16, J905.16, J907.16, RN102.8 (R7), U103.8 (A6), U204.15 (IO2), U303.27 (D6), U304.27 (D6), U401.27 (D6), U413.17 (D6), U414.17 (D6), U501.20 (D6), U602.18 (DQ6), U603.20 (DQ6), U604.20 (DQ6), U605.20 (DQ6), U606.20 (DQ6), U607.20 (DQ6), U608.20 (DQ6), U701.8 (D6), U803.17 (D6), U1001.27 (D6), U1101.4 (D6)
D7: J901.18, J903.18, J905.18, J907.18, RN102.9 (R8), U103.9 (A7), U204.14 (IO1), U303.26 (D7), U304.26 (D7), U401.26 (D7), U413.18 (D7), U414.18 (D7), U501.21 (D7), U602.19 (DQ7), U603.21 (DQ7), U604.21 (DQ7), U605.21 (DQ7), U606.21 (DQ7), U607.21 (DQ7), U608.21 (DQ7), U701.9 (D7), U803.18 (D7), U1001.26 (D7), U1101.3 (D7)
E: J901.17, J903.17, J905.17, J907.17, U101.34 (E), U102.1 (I1/CLK), U201.10 (Q), U303.25 (PHI2), U304.25 (PHI2), U401.25 (PHI2), U1001.25 (PHI2)
FLASHWREN: U102.10 (I10), U303.17 (PB7)
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C201.2, C202.2, C203.2, C204.2, C301.2, C302.2, C303.2, C304.2, C305.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C501.2, C502.2, C503.2, C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, C610.2, C701.2, C703.2, C801.2, C802.2, C803.1, C804.2, C805.2, C1001.2, C1002.2, C1003.2, H101.1, H102.1, H103.1, H104.1, H105.1, H106.1, H107.1, H108.1, H109.1, H110.1, H1001.1, H1002.1, H1003.1, H1004.1, J101.5, J101.13, J101.14, J201.2, J201.4, J201.6, J801.3 (GND), J801.5 (GND), J801.7 (GND), J801.15 (GND), J801.17 (GND), J801.18 (GND)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
HRB0: RN305.6 (R5), U303.2 (PA0), U607.28 (A13), U608.28 (A13)
HRB1: RN305.7 (R6), U303.3 (PA1), U607.3 (A14), U608.3 (A14)
HRB2: RN305.8 (R7), U303.4 (PA2), U607.31 (A15), U608.31 (A15)
HRB3: RN305.9 (R8), U303.5 (PA3), U607.2 (A16), U608.2 (A16)
HRB4: RN306.2 (R1), U303.6 (PA4), U607.30 (A17), U608.30 (A17)
HRB5: RN306.3 (R2), U303.7 (PA5), U607.1 (A18), U608.1 (A18)
HRB6: R301.1, U303.8 (PA6), U601.14 (A0)
INT3: U415.1, U701.34 (INTA)
INT7: U415.3, U701.17 (INTB)
IVV: U106.11 (I11), U411.18 (IO5)
LR0B0: RN304.2 (R1), U304.2 (PA0), U609.2 (I0a)
LR0B1: RN304.3 (R2), U304.3 (PA1), U609.5 (I0b)
LR0B2: RN304.4 (R3), U304.4 (PA2), U609.11 (I0c)
LR0B3: RN304.5 (R4), U304.5 (PA3), U609.14 (I0d)
LR0B4: RN304.6 (R5), U304.6 (PA4), U610.2 (I0a)
LR0B5: RN304.7 (R6), U304.7 (PA5), U610.5 (I0b)
LR1B0: RN304.8 (R7), U304.10 (PB0), U609.3 (I1a)
LR1B1: RN304.9 (R8), U304.11 (PB1), U609.6 (I1b)
LR1B2: RN305.2 (R1), U304.12 (PB2), U609.10 (I1c)
LR1B3: RN305.3 (R2), U304.13 (PB3), U609.13 (I1d)
LR1B4: RN305.4 (R3), U304.14 (PB4), U610.3 (I1a)
LR1B5: RN305.5 (R4), U304.15 (PB5), U610.6 (I1b)
unnamed: C108.1, D101.2 (A), R102.1, U108.2 (Vcc)
unnamed: D801.1 (K), R801.2
unnamed: D1001.1 (K), R1004.2
unnamed: D1002.1 (K), U1001.21 (~IRQ)
unnamed: J201.1, RN201.7 (R6), U204.5 (I5)
unnamed: J201.3, RN201.8 (R7), U204.6 (I6)
unnamed: J201.5, RN201.9 (R8), U204.7 (I7)
unnamed: J801.16 (PS_ON#), J802.1, U801.23 (D8)
unnamed: J803.1, U801.16 (D1)
unnamed: J803.2, U801.15 (D0)
unnamed: U101.31 (D0), U103.18 (B0)
unnamed: U101.30 (D1), U103.17 (B1)
unnamed: U101.29 (D2), U103.16 (B2)
unnamed: U101.28 (D3), U103.15 (B3)
unnamed: U101.27 (D4), U103.14 (B4)
unnamed: U101.26 (D5), U103.13 (B5)
unnamed: U101.25 (D6), U103.12 (B6)
unnamed: U101.24 (D7), U103.11 (B7)
unnamed: U101.32 (R/~W), U102.2 (I2), U103.1 (A->B), U106.3 (I3)
unnamed: U201.4 (C), U201.12 (C), U204.23 (IO10)
unnamed: U201.2 (J), U201.3 (~K), U201.9 (~Q)
unnamed: U202.2 (CP), X201.5 (OUT)
unnamed: U501.28 (A13), U502.3
unnamed: U501.29 (A14), U502.6
unnamed: U501.3 (A15), U502.8
unnamed: U501.2 (A16), U502.11
unnamed: U501.30 (A17), U503.3
unnamed: U501.1 (A18), U503.6
unnamed: U501.22 (CE), U503.8
unnamed: U502.5, U502.10, U502.13, U503.2, U503.5
unnamed: U601.2 (A0), U610.4 (Za)
unnamed: U601.3 (A1), U610.7 (Zb)
unnamed: U601.4 (O0), U603.22 (CE#)
unnamed: U601.5 (O1), U604.22 (CE#)
unnamed: U601.6 (O2), U605.22 (CE#)
unnamed: U601.7 (O3), U606.22 (CE#)
unnamed: U601.12 (O0), U607.22 (CE#)
unnamed: U601.11 (O1), U608.22 (CE#)
unnamed: U701.39 (RXA), U702.10 (TXD)
unnamed: U701.25 (RXB), U705.4 (TX)
unnamed: U701.38 (TXA), U702.14 (RXD)
unnamed: U701.26 (TXB), U705.5 (RX)
unnamed: U701.11 (XIN), X701.5 (OUT)
unnamed: U701.36 (~RTSA), U702.4 (~CTS)
unnamed: U701.23 (~RTSB), U705.2 (~CTS)
unnamed: U1001.18 (CB1), U1002.1
unnamed: U1001.19 (CB2), U1002.5
unnamed: U415.5, U1001.3 (PA1)
unnamed: U1001.10 (PB0), U1003.3 (Qa)
unnamed: U1001.11 (PB1), U1003.4 (Qb)
unnamed: U1001.12 (PB2), U1003.5 (Qc)
unnamed: U1001.13 (PB3), U1003.6 (Qd)
unnamed: U1001.14 (PB4), U1003.10 (Qe)
unnamed: U1001.15 (PB5), U1003.11 (Qf)
unnamed: U1001.16 (PB6), U1003.12 (Qg)
unnamed: U1001.17 (PB7), U1003.13 (Qh)
PWR_LED+: D801.2 (A), J101.8, U801.28 (D13)
PWR_LED-: J101.10, R802.2
Q: U101.35 (Q), U201.6 (Q), U201.13 (~K), U201.14 (J)
RB0: RN306.4 (R3), U303.10 (PB0), U502.1
RB1: RN306.5 (R4), U303.11 (PB1), U502.4
RB2: RN306.6 (R5), U303.12 (PB2), U502.9
RB3: RN306.7 (R6), U303.13 (PB3), U502.12
RB4: RN306.8 (R7), U303.14 (PB4), U503.1
RB5: RN306.9 (R8), U303.15 (PB5), U503.4
RESETH: U204.22 (IO9), U701.21 (RESET)
R/~W: J901.11, J903.11, J905.11, J907.11, RN101.2 (R1), U102.23 (IO10), U303.21 (R/~W), U304.21 (R/~W), U305.3 (A2), U401.21 (R/~W), U1001.22 (R/~W)
SD_LED+: D1001.2 (A), J101.7, U1002.8
SD_LED-: J101.9, R1005.2
dA0: U101.8 (A0), U104.18 (B0), U411.11 (I11)
dA1: U101.9 (A1), U104.17 (B1), U106.4 (I4)
dA2: U101.10 (A2), U104.16 (B2), U106.5 (I5)
dA3: U101.11 (A3), U104.15 (B3), U106.6 (I6)
dA4: U101.12 (A4), U104.14 (B4)
dA5: U101.13 (A5), U104.13 (B5)
dA6: U101.14 (A6), U104.12 (B6)
dA7: U101.15 (A7), U104.11 (B7)
dA8: U101.16 (A8), U105.18 (B0)
dA9: U101.17 (A9), U105.17 (B1)
dA10: U101.18 (A10), U105.16 (B2)
dA11: U101.19 (A11), U105.15 (B3)
dA12: U101.20 (A12), U105.14 (B4)
dA13: U101.21 (A13), U105.13 (B5)
dA14: U101.22 (A14), U105.12 (B6)
dA15: U101.23 (A15), U105.11 (B7)
nA0: RN101.3 (R2), U102.22 (IO9)
nA1: RN101.4 (R3), U102.21 (IO8)
nA2: RN101.5 (R4), U102.20 (IO7), U304.24 (CS1)
nA3: RN101.6 (R5), U102.19 (IO6), U701.16 (CHSEL)
nA3nA4: RN101.8 (R7), U102.17 (IO4), U303.22 (CS0), U304.22 (CS0)
nA4: RN101.7 (R6), U102.18 (IO5)
~BROMSEL: RN303.6 (R5), U301.14 (IO1), U503.9
~CLKSPD: U204.8 (I8), U305.11 (O4)
~FIRQ: RN201.2 (R1), U101.4 (~FIRQ)
~FLASHWR: RN201.5 (R4), U102.14 (IO1), U501.31 (PGM)
~FRAMSEL: RN303.8 (R7), U302.14 (IO1), U602.20 (CE#)
~FROMSEL: RN303.7 (R6), U301.15 (IO2), U502.2, U503.10
~HALT: J901.21, J903.21, J905.21, J907.21, RN201.3 (R2), U101.40 (~HALT)
~HBRAMSEL: RN303.9 (R8), U302.15 (IO2), U601.15 (E)
~IO0SEL: RN301.9 (R8), U301.16 (IO3), U303.23 (~CS2), U304.23 (~CS2), U305.4 (E1), U401.23 (~CS2)
~IO1SEL: RN301.8 (R7), U301.17 (IO4), U701.18 (~CS)
~IO2SEL: RN301.7 (R6), U301.18 (IO5), U1001.23 (~CS2)
~IO3SEL: RN301.6 (R5), U301.19 (IO6)
~IO4SEL: RN301.5 (R4), U301.20 (IO7)
~IO5SEL: RN301.4 (R3), U301.21 (IO8)
~IO6SEL: RN301.3 (R2), U301.22 (IO9)
~IO7SEL: RN301.2 (R1), U301.23 (IO10)
~IO8SEL: J901.23, J903.23, J905.23, J907.23, RN302.9 (R8), U302.16 (IO3)
~IO9SEL: J901.25, J903.25, J905.25, J907.25, RN302.8 (R7), U302.17 (IO4)
~IO10SEL: J901.27, J903.27, J905.27, J907.27, RN302.7 (R6), U302.18 (IO5)
~IO11SEL: J901.29, J903.29, J905.29, J907.29, RN302.6 (R5), U302.19 (IO6)
~IO12SEL: J901.31, J903.31, J905.31, J907.31, RN302.5 (R4), U302.20 (IO7)
~IO13SEL: J901.33, J903.33, J905.33, J907.33, RN302.4 (R3), U302.21 (IO8)
~IO14SEL: J901.35, J903.35, J905.35, J907.35, RN302.3 (R2), U302.22 (IO9)
~IO15SEL: J901.37, J903.37, J905.37, J907.37, RN302.2 (R1), U302.23 (IO10), U1101.11 (~CS)
~IRQ0: D1002.2 (A), RN401.2 (R1), U402.1
~IRQ1: RN401.3 (R2), U402.3
~IRQ2: RN401.4 (R3), U402.5
~IRQ3: RN401.5 (R4), U402.9, U415.2
~IRQ4: J901.20, J903.20, J905.20, J907.20, RN401.6 (R5), U402.11
~IRQ5: J901.22, J903.22, J905.22, J907.22, RN401.7 (R6), U402.13
~IRQ6: J901.24, J903.24, J905.24, J907.24, RN401.8 (R7), U403.1
~IRQ7: RN401.9 (R8), U403.3, U415.4
~IRQ8: J901.26, J903.26, J905.26, J907.26, RN402.2 (R1), U403.5
~IRQ9: J901.28, J903.28, J905.28, J907.28, RN402.3 (R2), U403.9
~IRQ10: J901.30, J903.30, J905.30, J907.30, RN402.4 (R3), U403.11
~IRQ11: J901.32, J903.32, J905.32, J907.32, RN402.5 (R4), U403.13
~IRQ12: RN402.6 (R5), U404.1
~IRQ13: J901.36, J903.36, J905.36, J907.36, RN402.7 (R6), U404.3
~IRQ14: J901.38, J903.38, J905.38, J907.38, RN402.8 (R7), U404.5
~IRQ15: RN402.9 (R8), U404.9, U1101.14 (~IRQ)
~IRQ: RN303.5 (R4), U101.3 (~IRQ), U411.17 (IO4)
~NMI: J101.3, SW101.1, U101.2 (~NMI), U107.1 (~RST)
~PSUCTL: U305.15 (O0), U801.18 (D3), U803.11 (Cp)
~PWRBUT: J101.12, SW801.1, U801.17 (D2)
~RD: J901.13, J903.13, J905.13, J907.13, RN101.9 (R8), U102.16 (IO3), U204.9 (I9), U501.24 (OE), U602.22 (OE#), U603.24 (OE#), U604.24 (OE#), U605.24 (OE#), U606.24 (OE#), U607.24 (OE#), U608.24 (OE#), U701.24 (~IOR), U1101.16 (~RD)
~RESET: J101.11, J901.19, J903.19, J905.19, J907.19, SW102.1, U101.37 (~RESET), U108.1 (~RST), U204.10 (I10), U303.34 (~RESET), U304.34 (~RESET), U401.34 (~RESET), U801.27 (D12), U1001.34 (~RESET), U1003.9 (~CLR), U1101.12 (~RESET)
~VBRH: U305.13 (O2), U414.11 (Cp)
~VBRL: U305.12 (O3), U413.11 (Cp)
~WR: J901.15, J903.15, J905.15, J907.15, RN201.4 (R3), U102.15 (IO2), U602.27 (WE#), U603.29 (WE#), U604.29 (WE#), U605.29 (WE#), U606.29 (WE#), U607.29 (WE#), U608.29 (WE#), U701.20 (~IOW), U1101.13 (~WR)
~aCPU: U104.19 (CE), U105.19 (CE), U106.18 (IO5)
~aINTC: U106.23 (IO10), U411.2 (I2), U413.1 (OE), U414.1 (OE)

## Code that names these connections

File psu-ctrl/psu-ctrl/psu-ctrl.ino (part):

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// ATMEL ATTINY45/85 / ARDUINO
//
//                  +-\/-+
// Ain0 (D 5) PB5  1|    |8  Vcc
// Ain3 (D 3) PB3  2|    |7  PB2 (D 2)  Ain1
// Ain2 (D 4) PB4  3|    |6  PB1 (D 1) pwm1
//            GND  4|    |5  PB0 (D 0) pwm0
//                  +----+
//

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
File gal-tests/addr_decode_test/addr_decode_test.ino (part):

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};

#define LBRAMSEL  0
#define FRAMSEL   1
#define IOSEL(x)  (FRAMSEL + 1 + (x))
#define HBRAMSEL  (IOSEL(31) + 1)
#define BROMSEL   (HBRAMSEL + 1)
#define FROMSEL   (BROMSEL + 1)

#define IOS(x)    ((x) * 32)            /* IO start */
#define IOE(x)    ((((x) + 1) * 32) - 1)/* IO end */

const struct signal_desc signal_map[] = {
[LBRAMSEL]  = { .name = "/LBRAM", .pin = -1 },    /* uses A15 directly */
[FRAMSEL]   = { .name = "/FRAM",  .pin = IN_FRAM },
[IOSEL(0)]  = { .name = "/IO0",   .pin = IN_IO0 },
[IOSEL(1)]  = { .name = "/IO1",   .pin = IN_IO1 },
[IOSEL(2)]  = { .name = "/IO2",   .pin = IN_IO2 },
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[IOSEL(29)] = { .name = "/IO29",  .pin = IN_IO29 },
[IOSEL(30)] = { .name = "/IO30",  .pin = IN_IO30 },
[IOSEL(31)] = { .name = "/IO31",  .pin = IN_IO31 },
[HBRAMSEL]  = { .name = "/HBRAM", .pin = IN_HBRAM },
[BROMSEL]   = { .name = "/BROM",  .pin = IN_BROM },
[FROMSEL]   = { .name = "/FROM",  .pin = IN_FROM },
};
#define signal_map_count (sizeof(signal_map) / sizeof(signal_map[0]))

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
## Commit log (part)

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2023-04-29 Initial empty KiCad project files.
2023-04-29 Logisim simulation of clock generator.
2023-05-03 Add the clock and reset generator circuit.
2023-05-09 Start the README.
2023-06-13 Add a GAL source file for the memory interface:
    - Generates /RD and /WR strobes based in E and R/W.
    - Generates a HALTED signal based on BA and BS.
    - Generates an IRQF (IRQ fetch) and FIRQF (FIRQ fetch) signals based on
    BA, BS, and A1..A3.
    - Generates a /FLASHWR strobe based on E, R/W, and the FLASHWREN signal.
    This GAL still has 4 inputs and 4 I/Os free.
2023-06-14 Re-factor to faciliate code sharing with the memory interface signal generator tester.
2023-06-18 Remove extra blank line.
2023-06-18 Rearrange the input pins to better match the arrangement of the output pins on the encoder GALs.
2023-06-18 Don't bother generating fuse and pin files.
2023-06-18 Add a memory interface GAL tester.
2023-06-18 Buffer the CPU's R/W signal in the memory interface GAL, reflecting it out the "RWO" signal.
2023-06-18 Add a test for mirroring R/W input -> RWO output.
2023-06-19 Document the memory map.
2023-06-19 Add an interrupt controller.
    The interrupt controller is made up of a PIA, plus 3 GALs (two as
    interrupt priority encoders with individual interrupt enables,
    and one as a multiplexer for those two encoders that provides a
    read-only pending-interrupt register and pulls the system /IRQ line
    low via a 2N7000). The 2 I/O ports on the PIA are used for the
    interrupt enables.
2023-06-19 Add the generated .chp and .jed files.
2023-06-19 Add text labels to address decoder and interrupt controller sheets.
2023-06-19 Rework the INTMUX to have CS0, CS1, and /CS2, like the PIA. Use the new nA2, along with A2 and A3 as additional chip-selects for these devices.
2023-06-20 Fix some printf format string issues.
2023-06-20 Add a sheet for the ROM interface.
2023-06-20 Compact the sub-sheets.
2023-06-24 Add a GAL programming script; it's just a wrapper around minipro, but it saves me typing.
2023-06-24 Duh, I don't need to eval the action.
2023-06-24 Allocate IRQ7 to the data UART, for now anyway.
2023-06-24 Connect the A5-A15 outputs of the 6809 directly to the inputs of the GALs that implement the address decoding logic.
2023-06-25 Re-arrange the outputs on the MEMINTF GAL, and drop the IRQF and FIRQF signals, since they're not going to be used at any point in the forseeable future. Leave the comments that describe decoding the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
2023-06-25 Re-arrange outputs on the MEMINTF GAL to make PCB layout easier.
2023-06-25 Add pull-ups to all of the address decoder outputs. Also connect pull-ups to /NMI, /IRQ, /FIRQ, and /HALT (using 4 spares in a resistor network on the address decoder).
2023-06-25 Finish assigning footprints.
2023-06-25 Add an experimental clock selection GAL.
2023-06-26 First cut at layout of the PCB.
2023-06-26 Correct footprint for FTDI breakout.
2023-06-26 Checkpoint: Lots of traces for the RAM.
2023-06-26 Checkpoint: Several ROM traces.
2023-06-26 Checkpoint: CPU connected to A and D buffers.
2023-06-26 Checkpoint: CPU clock connections.
2023-06-26 Checkpoint: All of the memory banking stuff is connected.
2023-06-27 Update the MEMINTF test harness for the removal of the IRQF and FIRQF signals.
2023-06-27 Add a PSU interface sheet. Super simple for now.
2023-06-27 Complete reset on the PCB...
2023-07-01 Add power LED handling. ON / OFF based on PSU state, or blinking when the power button is held for power-off.
2023-07-01 In loop(), use a switch() statement for improved readability.
2023-07-02 Minor tweaks.
2023-07-02 Connect the PSU controller to Port B of the ROM banking 65c21.
2023-07-02 Make 0 the POWEROFF command and 1 the RESET command. Fix comment about the command pins.
2023-07-03 More message cleanup. Ship it!
2023-07-03 Fix typo.
2023-07-04 No need to explicltly erase on a "program", since programming will do this already.
2023-07-07 Add an IVV (Interrupt Vector Valid) signal to the ABUSSEL.
2023-07-07 Adjustments now that there is a new ABUSSEL GAL in the circuit; don't bother with BA/BS anymore, also provide nA0 and nA1 signals.
2023-07-07 Integrate the auto-vectoring interrupt controller.
2023-07-07 Add enough of the expanion interface to start being able to fiddle with the PCB layout.
2023-07-09 WIP re-laying out PCB.
2023-07-10 Add +12v / -12v rails for the expansion interface.
2023-07-10 Add power planes and mounting holes (connected to GND).
2023-07-11 Move the UARTs down by the RAM chips.
2023-07-11 Remove IOxSEL 16-31 ... it was always ridiculous to have that many, and this lets me have 512 bytes more RAM in the fixed RAM region, plus eliminates 2 chips from the board.
2023-07-11 Name the Power button.
2023-07-11 Remove ADDRDEC2 and ADDRDEC3.
2023-07-11 Add the CLKSEL GAL and wire up the Clock Speed register into the IO0SEL memory map.
2023-07-12 PCB checkpoint.
2023-07-12 Checkpoint on expansion connectors.
2023-07-12 With relaxed severity for thermal reliefs and overlapping courtyards, this now passes DRC.
2023-07-12 Checkpoint (zones not filled).
2023-07-12 Add a 10uF tantalum capacitor for the CPU.
2023-07-12 Checkpoint with new layout.
2023-07-12 Revert "Replace the 74HC04 in the UART block with a 74HC14 -- we're going to use"
    This reverts commit c454c6436ca93ab385708a4f4269f39de4437bef.
    Actually, this isn't needed at all -- I can essentially replicate the
    reset circuit for this.
2023-07-13 Add 470uF caps to the +12V, -12V, and +3V3 rails. Increase the cap on the +5V rail to 2700uF.
2023-07-13 Move the reset connector to the front panel header.
2023-07-13 Route the non-+5V power rails.
2023-07-13 Add a place-holder for the SD Card SPI interface sheet.
2023-07-14 Checkpoint SD card interface. Need to add activity LED.
2023-07-14 Add SD Card activity LED.
2023-07-14 A ZIF socket also for the banked ROM.
2023-07-14 Assign IRQ0 to the SD Card interface.
2023-07-14 IRQ12 is reserved for keyboard, IRQ15 is reserved for video. Take them off of the expansion interface.
2023-07-14 Connect the power LED to the front panel header.
2023-07-16 Rearrange the truth tables and the equations slightly so they "count up".
2023-07-17 Add placeholders for human interface devices -- 2 SNES game ports and a placeholder for the PS/2 keyboard port (just a pin header there for now).
2023-07-17 Orient both SNES connectors properly.
2023-07-17 Add a README briefly describing the Logisim simulations.
2023-07-18 Move the PHI2/E input to the CLKSEL GAL up to pin 22, again, for board layout reasons.
2023-07-19 Clock generator video being posted.
2023-07-19 Pull-up /RESET on RN201.
2023-07-19 R102 and R103 are gone.
2023-07-21 Allow this to be built smol for ATtiny.
2023-07-21 Use physically smaller caps in the PSU.
2023-07-25 Add the Reset Generator video link.
2023-07-29 Add memory map and system register descriptions.
2023-07-29 Add PIA and VIA register definitions.
2023-07-29 Sense of the DDR access bit was wrong; correct it (0 == DDR, 1 == peripheral).
2023-07-29 Make pg09_defs.s indepenent of any other symbol definitions.
2023-07-29 Connect /CTS if the ACIA to ground.
2023-08-06 Define constants for max LBRAM and BROM banks.
2023-08-23 Fix up a comment.
2023-08-23 Make sure FLASHWREN always has a valid value by pulling it to GND.
2023-08-28 Disconnect the PSU controller from the ROM banker PIA and instead give it its own register (offset $11) in IO0SEL. Use a '138 to decode the address and generate the write strobe for it.
2023-08-28 Change U603 (the high banked RAM mux) from '138 to a '139 so it can also be used for the low banked RAM.
2023-08-28 Add a simulation for the I/O selector / write strobe generator for the PSU controller.
2023-08-28 Fix up the banker capacitors.
2023-08-28 Re-designate RAM components.
2023-08-29 Define max banks for HBRAM.
2023-08-29 Add another high banked SRAM, for a total of 128 banks.
2023-08-29 Fix a silk screen botch from adding the additional HBRAM SRAM chip.
2023-08-29 Move some silk screen a bit.
2023-10-22 Correct wiring mistake on High Banked RAM decoder: HRB6 needs to be connected to the A0 input.
2023-11-06 Tidy up the ROM sheet just a bit.
2024-01-30 Re-work low banked RAM so that not all SRAM chips have to be installed.
2024-02-06 Re-do the UARTs using a single TL16C2552 dual-UART in PLCC-44 package.
2024-02-08 KiCad whitespace change?
2024-02-08 Mystery whitepsace change by KiCad.
2024-02-08 Note the video is a VERA module connector.
2024-02-18 Add 2MHz clock output from the clock divider (it was previously not connected). This will be required by the PSG sound chip.
2024-02-18 MEMINTF needs A0-A4, not dA0-dA4.
2024-06-04 Add pull-down resistors to all bank selection signals to ensure that they won't be floating before the PIAs are initialized.
2024-06-06 Add a simulation of the LBRAM bank decoding.
2024-06-10 Oops, forgot to regen after this commit:
    Simplify the fixed-vs-banked ROM selection logic. Instead of using
    2 '157 selectors, just use 2 '08 AND gate chips. The bank signals
    are AND'd with /FROMSEL to force them to 0 when the fixed ROM is
    slected, and /FROMSEL and /BROMSEL are AND'd together to assert the
    flash ROM chip select whenever either one of them is asserted.
    This reverts the /FROMSEL and /BROMSEL logic in ADDRDEC0 back to the
2024-06-10 Add simulation for the auto-vectoring interrupt mux.
2024-06-10 OE -> nOE (it's active-low).
2024-06-10 Note that the chip select outputs are active-low.
2024-06-11 Weakly pull-down the INT_Ex signals to GND so the NAND inputs don't float if the PIA isn't initialized or is initialized incorrectly.
2024-06-11 Remove old tests that never really worked; I since have settled on a stragegy of simulation.
2024-06-11 Rename pg09_intmux_av.circ -> pg09_intc.circ; I'm going to put the entire interrupt controller simulation in this file.
2024-06-13 Add a bank number display.
2024-07-01 Fix set_output_signal() to actually use the passed-in pin #.
2024-07-08 Change the CLKSEL GAL to use /RD rather than R/W + E. Frees up a pin to use for other purposes in a separate change.
2024-07-08 Fix up BROM decoder simulation.
2024-07-08 Use a now-free pin on the CLKSEL GAL to invert /RESET into an active-high RESETH signal that can be used all over the system. Use RESETH with the 16550 UARTs and eliminate the 74HC14 Schmitt inverter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
2024-07-08 Eliminate the resistor network on the UART sheet -- it's no longer needed to pull up the IRQ lines (interrupt controller sheet does that). Just let the SPI sheet use its own discreet resistors.
2024-07-09 Switch the oscillators to half-can.
2024-07-09 Compact the layout around the clock generator.
2024-07-09 Move the 74AHC138 that strobes the VBR to the root sheet. In a future commit, this is going to become a common part for other system registers.
2024-07-10 Overhaul how the "system registers" in IO0SEL work, paving the way to use a VIA for the interrupt enables (because that would also give us a timer).
2024-07-10 Move the misc system register decoder to the address decoder sheet.
2024-07-10 Update for address decoding changes to misc system registers.
2025-07-12 Move psu-ctrl.ino into a subdirectory as expected by newer versions of the Arduino IDE.

Notices in the files:
gal-tests/addr_decode_test/addr_decode_test.ino:
Copyright (c) 2023 Jason R. Thorpe.
All rights reserved.
psu-ctrl/psu-ctrl/psu-ctrl.ino:
Copyright (c) 2023, 2025 Jason R. Thorpe.
design-files/pg09-system.kicad_pcb:
Copyright (c) 2023 Jason R. Thorpe. See LICENSE.
